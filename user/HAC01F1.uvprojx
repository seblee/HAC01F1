# Keil uVision project HAC01F1.uvprojx, settings and files
target HAC01F1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: F1 +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\user;..\stm32f0;..\drive;..\lib\inc;..\lib\src;..\kits;..\freemodbus-v1.5.0\modbus\functions;..\freemodbus-v1.5.0\modbus\include;..\freemodbus-v1.5.0\modbus\rtu;..\freemodbus-v1.5.0\demo\BARE\port;..\freemodbus-v1.5.0\demo\BARE;.\threads;.\CoreCtrl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main.c global_var.c daq.c calc.c alarm_calc.c event_record.c sys_status.c
    ./threads/: core_proc.c com_proc.c bkg_proc.c
  group corectrl
    ./CoreCtrl/: Acfrequency.c Fanctrl.c Phasecutting.c Sample.c Lib.c
  group drive
    ../drive/: adc.c systick.c uart.c led.c flash.c dio.c pid.c i2c_bsp.c
    ../stm32f0/: stm32f0xx_it.c
    ../lib/src/: stm32f0xx_iwdg.c
  group modbus
    ../lib/src/: stm32f0xx_flash.c
    ../freemodbus-v1.5.0/modbus/: mb.c
    ../freemodbus-v1.5.0/modbus/rtu/: mbcrc.c mbrtu.c
    ../freemodbus-v1.5.0/modbus/functions/: mbfuncdisc.c mbfuncholding.c mbutils.c
    ../freemodbus-v1.5.0/demo/BARE/port/: portevent.c portserial.c porttimer.c
    ../freemodbus-v1.5.0/demo/BARE/: mb_cb.c
  group kits
    ../kits/: fifo.c
  group lib
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_dac.c stm32f0xx_comp.c stm32f0xx_exti.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 1.5.0
